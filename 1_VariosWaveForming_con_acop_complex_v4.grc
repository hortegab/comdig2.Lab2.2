<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>samp_rate/2.</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>LPF BW (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>(samp_rate/2)/128.</value></param>
<param><key>stop</key><value>samp_rate/2.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,    -1.+0.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kd</value></param>
<param><key>value</key><value>math.pow(2,m)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>Constelacion</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>NodB</value></param>
<param><key>value</key><value>-65</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>No (in dB for white noise)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140.</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>0.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>samp_rate/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>TimingDelay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Timing</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>64./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hn</value></param>
<param><key>value</key><value>wform.nyq(Sps,ntaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hr</value></param>
<param><key>value</key><value>wform.rect(Sps,ntaps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hrc</value></param>
<param><key>value</key><value>wform.rcos(Sps,ntaps,rolloff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hrrc</value></param>
<param><key>value</key><value>wform.rrcos(Sps,ntaps,rolloff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>m</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(samp_rate_usrp/Kd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp</value></param>
<param><key>value</key><value>100000000</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx</value></param>
<param><key>stream_id</key><value>Rect</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_0</value></param>
<param><key>stream_id</key><value>T2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1</value></param>
<param><key>stream_id</key><value>Rect_a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_3_0_0</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>ojo@0</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"Acoplamiento.Rect"</value></param>
<param><key>Ymax</key><value>3</value></param>
<param><key>Ymin</key><value>-3</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>ojo@1</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"Acoplamiento.Nyq"</value></param>
<param><key>Ymax</key><value>3</value></param>
<param><key>Ymin</key><value>-3</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0_0_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>ojo@2</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"Acoplamiento.RC"</value></param>
<param><key>Ymax</key><value>3</value></param>
<param><key>Ymin</key><value>-3</value></param>
</block>
<block>
<key>b_Eye_Diagram_simple_c</key>
<param><key>id</key><value>b_Eye_Diagram_simple_c_0_0_1</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay_i</key><value>0</value></param>
<param><key>gui_hint</key><value>ojo@3</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>Kint</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate1</key><value>samp_rate</value></param>
<param><key>Sps1</key><value>Sps</value></param>
<param><key>Title</key><value>"Acoplamiento.RRC"</value></param>
<param><key>Ymax</key><value>3</value></param>
<param><key>Ymin</key><value>-3</value></param>
</block>
<block>
<key>b_Mod_BPSK_bc</key>
<param><key>id</key><value>b_Mod_BPSK_bc_0</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0_0</value></param>
<param><key>DelayDiez</key><value>TimingDelay</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>MiconstellationObject</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1</value></param>
<param><key>stream_id</key><value>Rect</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_0</value></param>
<param><key>stream_id</key><value>Nyq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_0_0</value></param>
<param><key>stream_id</key><value>RRC</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>RRC_a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_0_1</value></param>
<param><key>stream_id</key><value>Nyq_a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_1</value></param>
<param><key>stream_id</key><value>RC</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_1_0</value></param>
<param><key>stream_id</key><value>RC_a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_1_2</value></param>
<param><key>stream_id</key><value>Rect_a</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>numpy.multiply(hr,1./Sps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>hr</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0_0</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>hn</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0_0_0</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>hrc</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0_0_1</value></param>
<param><key>interp</key><value>Sps</value></param>
<param><key>taps</key><value>hrrc</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>numpy.multiply(hn,1./Sps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_1_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>numpy.multiply(hrrc,1./Sps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_2</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>numpy.multiply(hrc,1./Sps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>CAPA1 MODULACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>CAPA0.1.Shap.Acop.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>ojo</value></param>
<param><key>gui_hint</key><value>pestana@4</value></param>
<param><key>label0</key><value>Rectangular</value></param>
<param><key>label1</key><value>Nyquist</value></param>
<param><key>label2</key><value>Raised Cosine</value></param>
<param><key>label3</key><value>Root Raised Cosine</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>pestana</value></param>
<param><key>gui_hint</key><value>1,0,1,4</value></param>
<param><key>label0</key><value>Osciloscopio Wave Forming</value></param>
<param><key>label1</key><value>PSD Wave Forming</value></param>
<param><key>label2</key><value>Osciloscopio Acoplamiento</value></param>
<param><key>label3</key><value>PSD Acoplamiento</value></param>
<param><key>label4</key><value>Diagrama de Ojo</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>pestana@1:0,0</value></param>
<param><key>label1</key><value>Rect</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>label2</key><value>Nyq</value></param>
<param><key>width2</key><value>3</value></param>
<param><key>label3</key><value>RC</value></param>
<param><key>width3</key><value>3</value></param>
<param><key>label4</key><value>RRC</value></param>
<param><key>width4</key><value>3</value></param>
<param><key>name</key><value>"Wave Forming.PSD"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>pestana@0:0,0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Re.Nyq</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Re.Nyq</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>Re.RC</value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value>Re.RC</value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value>Re.RRC</value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value>Re.RRC</value></param>
<param><key>name</key><value>"Wave Forming"</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>int(Tmax_scope*samp_rate)/4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>3</value></param>
<param><key>ymin</key><value>-3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_0_0</value></param>
<param><key>stream_id</key><value>R2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1</value></param>
<param><key>stream_id</key><value>RRC</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_1</value></param>
<param><key>stream_id</key><value>RC</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_1_0</value></param>
<param><key>stream_id</key><value>Nyq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_1_0_0</value></param>
<param><key>stream_id</key><value>Nyq_a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_1_1</value></param>
<param><key>stream_id</key><value>RC_a</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>s1_1_0_1_2</value></param>
<param><key>stream_id</key><value>RRC_a</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>wform</value></param>
<param><key>source_code</key><value>import math
import numpy
#######################################################
##        Hecho por Homero Ortega Boada              ##
##        comdiguis@saber.uis.edu.co                 ##
##     Universidad Industrial de Santander           ##
#######################################################

#######################################################
##               Forma rectangular                   ##
#######################################################                       
def rect(Sps,ntaps):
    h=ntaps*[0,]
    for n in range(Sps):
        k=int(ntaps/2) # esto es para que h[n] quede centrada en la mitad del vector
        h[k-n]=1.
    return h

#######################################################
##               Forma de Nyquist                    ##
#######################################################                       
def nyq(Sps,ntaps):
    ntaps_min=-int(ntaps/2)
    ntaps_max=abs(ntaps_min)-1+int(math.ceil(ntaps/2.-abs(ntaps_min)))
    h=ntaps*[0,]
    for n in range(ntaps):
        k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
        h[n]=numpy.sinc(k/Sps)
    Amp=numpy.amax(h)
    return h/Amp

#######################################################
##               Forma Coseno Alzado                 ##
#######################################################                       
def rcos(Sps,ntaps,beta):
    if beta==0:
        h=nyq(Sps,ntaps)
    else:
        h=ntaps*[0,]
        for n in range(ntaps):
            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
            if abs(k)==Sps/(2.*beta):
                h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
            else:
                h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
    Amp=numpy.amax(h)
    return h/Amp

#######################################################
##            Forma Raiz de Coseno Alzado            ##
#######################################################                       

def rrcos(Sps,ntaps,beta):
    if beta==0:
        h=nyq(Sps,ntaps)
    else:
        h=ntaps*[0,]
        beta4=4.*beta
        for n in range(ntaps):
            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
            if k==0:
                h[n]=1+beta*(4./math.pi-1.)
            elif abs(k)==Sps/beta4:
                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                h[n]=(ha+hb)*beta/math.sqrt(2.)
            else:
                ks=k/Sps
                kspi=math.pi*ks
                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                Den=kspi*(1.-(beta4*ks)**2)
                h[n]=Num/Den                
    Amp=numpy.amax(h)
    return h/Amp
</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>Tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>b_Mod_BPSK_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_bc_0</source_block_id><sink_block_id>Tx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Mod_BPSK_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0_0</source_block_id><sink_block_id>Tx_3_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>s1_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_1_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>e1_0_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>e1_0_1_0_0_0</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1_0_1</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>e1_0_1_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>e1_0_1_1_0</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_1_2</source_block_id><sink_block_id>b_Eye_Diagram_simple_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>Tx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>b_sampler_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>Tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>s1_1_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>s1_1_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0_1</source_block_id><sink_block_id>s1_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_1</source_block_id><sink_block_id>s1_1_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_1_0</source_block_id><sink_block_id>s1_1_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_2</source_block_id><sink_block_id>s1_1_0_1_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
